# Keil uVision project GD32F303CB.uvprojx, settings and files
target GD32F303CB (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: GD32F303CB GigaDevice
  pack: GigaDevice.GD32F30x_DFP.2.6.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x08000000,0x020000) CPUTYPE("Cortex-M4") FPU2 CLOCK(8000000) ELITTLE
  output: Project +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,GD32F30X_HD
  c include: ..\..\sdk\GD32F30x_Firmware_Library_V3.0.3\Firmware\CMSIS;..\..\sdk\GD32F30x_Firmware_Library_V3.0.3\Firmware\CMSIS\GD\GD32F30x\Include;..\..\sdk\GD32F30x_Firmware_Library_V3.0.3\Firmware\GD32F30x_standard_peripheral\Include;.
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Application
    ./: main.c
  group CMSIS
    ./: system_gd32f30x.c
  group Peripherals
    ../../sdk/GD32F30x_Firmware_Library_V3.0.3/Firmware/GD32F30x_standard_peripheral/Source/: gd32f30x_gpio.c gd32f30x_rcu.c
  group Startup
    ../../sdk/GD32F30x_Firmware_Library_V3.0.3/Firmware/CMSIS/GD/GD32F30x/Source/ARM/: startup_gd32f30x_hd.s
software components: CMSIS:CORE 5.5.0
